# Keil uVision project Add 2-16 bit.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Add 2-16 bit
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Add 2-16 bit/: 16 bit addition.asm
