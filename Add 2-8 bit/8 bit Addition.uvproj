# Keil uVision project 8 bit Addition.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8 bit Addition
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 8 bit Addition.asm
    ./8 bit subtraction/: 8 bit subtraction.asm
